# Keil uVision project fly.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: fly +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F411xE
  c include: .\user;.\start;.\Drivers\BSP;.\Drivers\Devices;.\Middlewares\eMPL;.\Middlewares\freertos;.\Middlewares\freertos\portable\RVDS\ARM_CM4F;.\Modules\Algorithm;.\Middlewares\library;.\Middlewares\freertos\portable\RVDS\ARM_CM4F;.\Middlewares\freertos\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group bsp
    ./Drivers/BSP/: bsp_adc.c bsp_adc.h bsp_i2c_soft.c bsp_i2c_soft.h bsp_spi.c bsp_spi.h bsp_usart.c bsp_usart.h Delay.c Delay.h
  group devices
    ./Drivers/Devices/: dev_motor.c dev_motor.h dev_mpu6050.c dev_mpu6050.h dev_mpu6050_reg.h dev_nrf24l01.c dev_nrf24l01.h OLED.c OLED.h OLED_Font.h
  group empl
    ./Middlewares/eMPL/: dmpKey.h dmpmap.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h
  group freertos
    ./Middlewares/freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./Middlewares/freertos/portable/RVDS/ARM_CM4F/: port.c portmacro.h
    ./Middlewares/freertos/portable/MemMang/: heap_4.c
  group library
    ./Middlewares/library/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group alg
    ./Modules/Algorithm/: alg_imu.c alg_imu.h alg_pid.c alg_pid.h
  group start
    ./start/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f411xe.s stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
  group user
    ./user/: main.c main.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
